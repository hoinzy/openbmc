FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-hwmon-temp-add-NCT6796-I2C-device-type.patch"
