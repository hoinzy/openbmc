FILESEXTRAPATHS:prepend:trx40d8-2n2t := "${THISDIR}/${PN}:"
